# IAR project lib_amazon.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: __thumb2__; CONFIG_PLATFORM_8710C; __ARM_ARCH_8M_MAIN__=1; CONFIG_BUILD_RAM=1; _NO_DEFINITIONS_IN_HEADER_FILES; V8M_STKOVF; ENABLE_AMAZON_COMMON; MBEDTLS_CONFIG_FILE="aws_mbedtls_config.h"
  ICCARM.IExtraOptions: --cmse; --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\component\soc\realtek\8710c\cmsis\rtl8710c\include; ..\..\..\component\soc\realtek\8710c\cmsis\rtl8710c\lib\include; ..\..\..\component\soc\realtek\8710c\fwlib\include; ..\..\..\component\soc\realtek\8710c\fwlib\lib\include; ..\..\..\component\soc\realtek\8710c\cmsis\cmsis-core\include; ..\..\..\component\soc\realtek\8710c\app\rtl_printf\include; ..\..\..\component\soc\realtek\8710c\app\shell; ..\..\..\component\soc\realtek\8710c\app\stdio_port; ..\..\..\component\soc\realtek\8710c\misc\utilities\include; ..\..\..\component\soc\realtek\8710c\mbed-drivers\include; ..\..\..\component\soc\realtek\8710c\misc\platform; ..\..\..\component\soc\realtek\8710c\misc\driver; ..\..\..\component\soc\realtek\8710c\misc\os; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v10.4.3\include; ..\..\..\component\os\freertos\freertos_v10.4.3\portable\GCC\ARM_CM33_NTZ\non_secure; ..\..\..\component\common\api; ..\..\..\component\common\api\at_cmd; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src\crypto; ..\..\..\component\common\api\network\include; ..\..\..\component\common\application; ..\..\..\component\common\application\mqtt\MQTTClient; ..\..\..\component\common\application\mqtt\MQTTPacket\V5; ..\..\..\component\common\application\mqtt\MQTTPacket; ..\..\..\component\common\example; ..\..\..\component\common\file_system; ..\..\..\component\common\file_system\dct; ..\..\..\component\common\file_system\fatfs; ..\..\..\component\common\file_system\fatfs\r0.10c\include; ..\..\..\component\common\file_system\ftl; ..\..\..\component\common\utilities; ..\..\..\component\common\mbed\hal; ..\..\..\component\common\mbed\hal_ext; ..\..\..\component\common\mbed\targets\hal\rtl8710c; ..\..\..\component\common\network; ..\..\..\component\common\network\coap\include; ..\..\..\component\common\network\libcoap\include; ..\..\..\component\common\network\http2\nghttp2-1.31.0\includes; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\lib_amazon\freertos_LTS\libraries\3rdparty\mbedtls\include; ..\..\..\lib_amazon\freertos_LTS\libraries\3rdparty\mbedtls_config; ..\..\..\lib_amazon\freertos_LTS\libraries\3rdparty\mbedtls_utils; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\common\drivers\wlan\realtek\src\core\option; ..\..\..\component\common\test; ..\..\..\component\common\bluetooth\realtek\sdk; ..\..\..\component\common\bluetooth\realtek\sdk\inc; ..\..\..\component\common\bluetooth\realtek\sdk\inc\app; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\gap; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\client; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\server; ..\..\..\component\common\bluetooth\realtek\sdk\inc\os; ..\..\..\component\common\bluetooth\realtek\sdk\inc\platform; ..\..\..\component\common\bluetooth\realtek\sdk\inc\stack; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebaz2\lib; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebaz2\src; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebaz2\src\data_uart; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebaz2\src\hci; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebaz2\src\os; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebaz2\src\vendor_cmd; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_config; ..\..\..\component\common\bluetooth\realtek\sdk\example\ble_central; ..\..\..\component\common\bluetooth\realtek\sdk\example\ble_peripheral; ..\..\..\component\common\bluetooth\realtek\sdk\example\ble_scatternet; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_fuzz_test; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_ota_central_client; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_datatrans; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_ancs; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_joylink_adapter; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\cmd; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\common; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\gap; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\inc; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\inc\amebaz2; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\model; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\model\realtek; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\platform; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\profile; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\utility; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\provisioner; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\device; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api\common; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api\provisioner; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api\device; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_provisioner_rtk_demo; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_provisioner_rtk_demo\inc; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_device_rtk_demo; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_multiple_profile\device_multiple_profile; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_multiple_profile\provisioner_multiple_profile; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_test; ..\..\..\component\common\bluetooth\realtek\sdk\src\mcu\module\data_uart_cmd; ..\..\..\component\common\bluetooth\realtek\sdk\board\common\inc; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_airsync_config; ..\..\..\component\common\media\rtp_codec; ..\..\..\component\common\media\mmfv2; ..\..\..\component\common\application\airsync\1.0.4; ..\..\..\component\os\os_dep\include; ..\..\..\component\common\application\amazon\amazon-ffs\ffs_demo\common\include; ..\..\..\component\common\application\amazon\amazon-ffs\ffs_demo\realtek\configs; ..\..\..\component\common\example\amazon_freertos; ..\..\..\lib_amazon\freertos_LTS\libraries\freertos_plus\standard\utils\include; ..\..\..\lib_amazon\freertos_LTS\libraries\logging\include; ..\..\..\lib_amazon\freertos_LTS\libraries\abstractions\wifi\include; ..\..\..\lib_amazon\freertos_LTS\libraries\3rdparty\unity\src; ..\..\..\lib_amazon\freertos_LTS\libraries\3rdparty\unity\extras\fixture\src; ..\..\..\lib_amazon\freertos_LTS\libraries\c_sdk\standard\common\include; ..\..\..\lib_amazon\freertos_LTS\libraries\abstractions\platform\freertos\include; ..\..\..\lib_amazon\freertos_LTS\libraries\abstractions\platform\include; ..\..\..\lib_amazon\freertos_LTS\libraries\abstractions\secure_sockets\include; ..\..\..\lib_amazon\freertos_LTS\libraries\c_sdk\standard\common\include\private; ..\..\..\lib_amazon\freertos_LTS\libraries\abstractions\pkcs11\corePKCS11\source\include; ..\..\..\lib_amazon\freertos_LTS\libraries\abstractions\pkcs11\corePKCS11\source\dependency\3rdparty\pkcs11; ..\..\..\lib_amazon\freertos_LTS\libraries\c_sdk\standard\common\include\private; ..\..\..\lib_amazon\freertos_LTS\libraries\c_sdk\standard\common\include\private; ..\..\..\lib_amazon\freertos_LTS\libraries\abstractions\backoff_algorithm\source\include; ..\..\..\lib_amazon\freertos_LTS\libraries\coreHTTP\source\include; ..\..\..\lib_amazon\freertos_LTS\libraries\coreHTTP\source\interface; ..\..\..\lib_amazon\freertos_LTS\libraries\abstractions\transport\secure_sockets; ..\..\..\lib_amazon\freertos_LTS\libraries\coreMQTT\source\include; ..\..\..\lib_amazon\freertos_LTS\libraries\3rdparty\jsmn; ..\..\..\lib_amazon\freertos_LTS\libraries\freertos_plus\aws\ota\include; ..\..\..\lib_amazon\freertos_LTS\libraries\3rdparty\mbedtls_utils; ..\..\..\lib_amazon\freertos_LTS\libraries\freertos_plus\standard\crypto\include; ..\..\..\lib_amazon\freertos_LTS\demos\dev_mode_key_provisioning\include; ..\..\..\lib_amazon\freertos_LTS\libraries\c_sdk\aws\defender\include; ..\..\..\lib_amazon\freertos_LTS\libraries\c_sdk\standard\mqtt\include; ..\..\..\lib_amazon\freertos_LTS\libraries\c_sdk\standard\serializer\include; ..\..\..\lib_amazon\freertos_LTS\libraries\c_sdk\aws\shadow\include; ..\..\..\lib_amazon\freertos_LTS\libraries\c_sdk\standard\mqtt\test\access; ..\..\..\lib_amazon\freertos_LTS\libraries\coreHTTP\source\dependency\3rdparty\http_parser; ..\..\..\lib_amazon\freertos_LTS\libraries\c_sdk\standard\https\include; ..\..\..\lib_amazon\freertos_LTS\libraries\c_sdk\standard\https\test\access; ..\..\..\lib_amazon\freertos_LTS\libraries\c_sdk\standard\mqtt\src; ..\..\..\lib_amazon\freertos_LTS\libraries\c_sdk\standard\mqtt\test\mock; ..\..\..\lib_amazon\freertos_LTS\libraries\3rdparty\tinycbor\src; ..\..\..\lib_amazon\freertos_LTS\libraries\freertos_plus\aws\ota\src; ..\..\..\lib_amazon\freertos_LTS\libraries\freertos_plus\standard\tls\include; ..\..\..\lib_amazon\freertos_LTS\demos\common\pkcs11_helpers; ..\..\..\lib_amazon\freertos_LTS\demos\include; ..\..\..\lib_amazon\freertos_LTS\demos\network_manager; ..\..\..\lib_amazon\freertos_LTS\vendors\realtek\boards\amebaZ2\aws_demos\config_files; ..\..\..\lib_amazon\freertos_LTS\demos\common\http_demo_helpers; ..\..\..\lib_amazon\freertos_LTS\libraries\device_shadow_for_aws\source\include; ..\..\..\lib_amazon\freertos_LTS\libraries\coreJSON\source\include; ..\..\..\lib_amazon\freertos_LTS\demos\common\mqtt_demo_helpers; ..\..\..\lib_amazon\freertos_LTS\libraries\freertos_plus\aws\ota\test; ..\..\..\lib_amazon\freertos_LTS\libraries\jobs_for_aws\source\include; ..\..\..\lib_amazon\freertos_LTS\libraries\device_defender_for_aws\source\include; ..\..\..\lib_amazon\freertos_LTS\demos\device_defender_for_aws; ..\..\..\lib_amazon\freertos_LTS\libraries\abstractions\platform\include\platform; ..\..\..\lib_amazon\freertos_LTS\libraries\coreMQTT-Agent\source\include; ..\..\..\lib_amazon\freertos_LTS\libraries\abstractions\mqtt_agent\include; ..\..\..\lib_amazon\freertos_LTS\demos\common\mqtt_subscription_manager; ..\..\..\lib_amazon\freertos_LTS\libraries\ota_for_aws\source\include; ..\..\..\lib_amazon\freertos_LTS\libraries\ota_for_aws\source; ..\..\..\lib_amazon\freertos_LTS\libraries\ota_for_aws\source\portable; ..\..\..\lib_amazon\freertos_LTS\libraries\ota_for_aws\source\portable\os; ..\..\..\lib_amazon\freertos_LTS\libraries\abstractions\mqtt_agent\include; ..\..\..\lib_amazon\freertos_LTS\vendors\realtek\boards\amebaZ2\ports\ota; ..\..\..\lib_amazon\freertos_LTS\libraries\coreMQTT-Agent\source\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lib_amazon.out
  group demo/common
    ../../../lib_amazon/freertos_LTS/demos/common/http_demo_helpers/: http_demo_utils.c
    ../../../lib_amazon/freertos_LTS/demos/common/mqtt_demo_helpers/: mqtt_demo_helpers.c
    ../../../lib_amazon/freertos_LTS/demos/common/mqtt_subscription_manager/: mqtt_subscription_manager.c
    ../../../lib_amazon/freertos_LTS/demos/common/ota_demo_helpers/: ota_application_version.c
    ../../../lib_amazon/freertos_LTS/demos/common/pkcs11_helpers/: pkcs11_helpers.c
  group demo/coreHTTP
    ../../../lib_amazon/freertos_LTS/demos/coreHTTP/: http_demo_mutual_auth.c
  group demo/coreMQTT
    ../../../lib_amazon/freertos_LTS/demos/coreMQTT/: mqtt_demo_mutual_auth.c
  group demo/coreMQTT_Agent
    ../../../lib_amazon/freertos_LTS/demos/coreMQTT_Agent/: mqtt_agent_task.c simple_sub_pub_demo.c subscription_manager.c
  group demo/demo_runner
    ../../../lib_amazon/freertos_LTS/demos/demo_runner/: aws_demo.c iot_demo_freertos.c iot_demo_runner.c
  group demo/dev_mode_key_provisioning
    ../../../lib_amazon/freertos_LTS/demos/dev_mode_key_provisioning/src/: aws_dev_mode_key_provisioning.c
  group demo/device_defender_for_aws
    ../../../lib_amazon/freertos_LTS/demos/device_defender_for_aws/: defender_demo.c report_builder.c
    ../../../lib_amazon/freertos_LTS/demos/device_defender_for_aws/metrics_collector/lwip/: metrics_collector.c
  group demo/device_shadow_for_aws
    ../../../lib_amazon/freertos_LTS/demos/device_shadow_for_aws/: shadow_demo_main.c
  group demo/jobs_for_aws
    ../../../lib_amazon/freertos_LTS/demos/jobs_for_aws/: jobs_demo.c
  group demo/network_manager
    ../../../lib_amazon/freertos_LTS/demos/network_manager/: aws_iot_network_manager.c
  group demo/ota
    ../../../lib_amazon/freertos_LTS/demos/ota/ota_demo_core_http/: ota_demo_core_http.c
    ../../../lib_amazon/freertos_LTS/demos/ota/ota_demo_core_mqtt/: ota_demo_core_mqtt.c
  group libraries/3rdparty/jsmn
    ../../../lib_amazon/freertos_LTS/libraries/3rdparty/jsmn/: jsmn.c
  group libraries/3rdparty/mbedtls_utils
    ../../../lib_amazon/freertos_LTS/libraries/3rdparty/mbedtls_utils/: mbedtls_error.c mbedtls_utils.c
  group libraries/3rdparty/tinycbor
    ../../../lib_amazon/freertos_LTS/libraries/3rdparty/tinycbor/src/: cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborparser.c cborparser_dup_string.c cborpretty.c cborpretty_stdio.c cborvalidation.c
  group libraries/abstractions/backoff_algorithm
    ../../../lib_amazon/freertos_LTS/libraries/abstractions/backoff_algorithm/source/: backoff_algorithm.c
  group libraries/abstractions/mqtt_agent
    ../../../lib_amazon/freertos_LTS/libraries/abstractions/mqtt_agent/: freertos_agent_message.c freertos_command_pool.c
  group libraries/abstractions/pkcs11
    ../../../lib_amazon/freertos_LTS/libraries/abstractions/pkcs11/corePKCS11/source/: core_pkcs11.c core_pki_utils.c
    ../../../lib_amazon/freertos_LTS/libraries/abstractions/pkcs11/corePKCS11/source/portable/mbedtls/: core_pkcs11_mbedtls.c
  group libraries/abstractions/platform
    ../../../lib_amazon/freertos_LTS/libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_metrics.c iot_network_freertos.c iot_threads_freertos.c
  group libraries/abstractions/transport/secure_sockets
    ../../../lib_amazon/freertos_LTS/libraries/abstractions/transport/secure_sockets/: transport_secure_sockets.c
  group libraries/c_sdk
    ../../../lib_amazon/freertos_LTS/libraries/c_sdk/standard/common/: iot_device_metrics.c iot_init.c iot_static_memory_common.c
  group libraries/c_sdk/taskpool
    ../../../lib_amazon/freertos_LTS/libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group libraries/coreHTTP
    ../../../lib_amazon/freertos_LTS/libraries/coreHTTP/source/: core_http_client.c
    ../../../lib_amazon/freertos_LTS/libraries/coreHTTP/source/dependency/3rdparty/http_parser/: http_parser.c
  group libraries/coreJSON
    ../../../lib_amazon/freertos_LTS/libraries/coreJSON/source/: core_json.c
  group libraries/coreMQTT
    ../../../lib_amazon/freertos_LTS/libraries/coreMQTT/source/: core_mqtt.c core_mqtt_serializer.c core_mqtt_state.c
  group libraries/coreMQTT-Agent
    ../../../lib_amazon/freertos_LTS/libraries/coreMQTT-Agent/source/: core_mqtt_agent.c core_mqtt_agent_command_functions.c
  group libraries/device_defender_for_aws
    ../../../lib_amazon/freertos_LTS/libraries/device_defender_for_aws/source/: defender.c
  group libraries/device_shadow_for_aws
    ../../../lib_amazon/freertos_LTS/libraries/device_shadow_for_aws/source/: shadow.c
  group libraries/freertos_plus/crypto
    ../../../lib_amazon/freertos_LTS/libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
  group libraries/freertos_plus/tls
    ../../../lib_amazon/freertos_LTS/libraries/freertos_plus/standard/tls/src/: iot_tls.c
  group libraries/freertos_plus/utils
    ../../../lib_amazon/freertos_LTS/libraries/freertos_plus/standard/utils/src/: iot_system_init.c
  group libraries/jobs_for_aws
    ../../../lib_amazon/freertos_LTS/libraries/jobs_for_aws/source/: jobs.c
  group libraries/logging
    ../../../lib_amazon/freertos_LTS/libraries/logging/: iot_logging.c iot_logging_task_dynamic_buffers.c
  group libraries/ota_for_aws
    ../../../lib_amazon/freertos_LTS/libraries/ota_for_aws/source/: ota.c ota_base64.c ota_cbor.c ota_http.c ota_interface.c ota_mqtt.c
  group libraries/ota_for_aws/portable
    ../../../lib_amazon/freertos_LTS/libraries/ota_for_aws/source/portable/os/: ota_os_freertos.c
  group vendor
    ../../../lib_amazon/freertos_LTS/vendors/realtek/boards/amebaZ2/aws_demos/application_code/: aws_main.c
  group vendor/ota
    ../../../lib_amazon/freertos_LTS/vendors/realtek/boards/amebaZ2/ports/ota/: aws_ota_amebaZ2.c ota_pal.c
  group vendor/pkcs11
    ../../../lib_amazon/freertos_LTS/vendors/realtek/boards/amebaZ2/ports/pkcs11/: core_pkcs11_pal.c
  group vendor/secure_sockets
    ../../../lib_amazon/freertos_LTS/vendors/realtek/boards/amebaZ2/ports/secure_sockets/: iot_secure_sockets.c
  group vendor/wifi
    ../../../lib_amazon/freertos_LTS/vendors/realtek/boards/amebaZ2/ports/wifi/: iot_wifi.c
