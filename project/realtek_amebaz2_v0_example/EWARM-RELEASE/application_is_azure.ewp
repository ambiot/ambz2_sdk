# IAR project application_is_azure.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default  None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: __thumb2__; CONFIG_PLATFORM_8710C; __ARM_ARCH_8M_MAIN__=1; CONFIG_BUILD_RAM=1; _NO_DEFINITIONS_IN_HEADER_FILES; V8M_STKOVF; CONFIG_SYSTEM_TIME64=0
  ICCARM.IExtraOptions: --cmse; --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\component\soc\realtek\8710c\cmsis\rtl8710c\include; ..\..\..\component\soc\realtek\8710c\cmsis\rtl8710c\lib\include; ..\..\..\component\soc\realtek\8710c\fwlib\include; ..\..\..\component\soc\realtek\8710c\fwlib\lib\include; ..\..\..\component\soc\realtek\8710c\cmsis\cmsis-core\include; ..\..\..\component\soc\realtek\8710c\cmsis\rtl8710c\include; ..\..\..\component\soc\realtek\8710c\app\rtl_printf\include; ..\..\..\component\soc\realtek\8710c\app\shell; ..\..\..\component\soc\realtek\8710c\app\stdio_port; ..\..\..\component\soc\realtek\8710c\misc\utilities\include; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v10.0.1\Source\include; ..\..\..\component\os\freertos\freertos_v10.0.1\Source\portable\IAR\ARM_RTL8710C; ..\..\..\component\common\api; ..\..\..\component\common\api\at_cmd; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\network\include; ..\..\..\component\common\application; ..\..\..\component\common\application\mqtt\MQTTClient; ..\..\..\component\common\example; ..\..\..\component\common\file_system; ..\..\..\component\common\file_system\dct; ..\..\..\component\common\file_system\ftl; ..\..\..\component\common\utilities; ..\..\..\component\common\mbed\hal; ..\..\..\component\common\mbed\hal_ext; ..\..\..\component\common\mbed\targets\hal\rtl8710c; ..\..\..\component\soc\realtek\8710c\mbed-drivers\include; ..\..\..\component\os\os_dep\include; ..\..\..\component\common\network; ..\..\..\component\common\network\coap\include; ..\..\..\component\common\network\http2\nghttp2-1.31.0\includes; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\common\network\ssl\mbedtls-2.4.0\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\common\mbed\targets\hal\rtl8710c; ..\..\..\component\common\test; ..\..\..\component\soc\realtek\8710c\misc\platform; ..\..\..\component\soc\realtek\8710c\misc\driver; ..\..\..\component\soc\realtek\8710c\misc\os; ..\..\..\component\common\drivers\wlan\realtek\src\core\option; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src\crypto; ..\..\..\component\common\file_system\fatfs; ..\..\..\component\common\file_system\fatfs\r0.10c\include; ..\..\..\component\common\application\azure\azure-sdk-for-c\sdk\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: V8M_STKOVF
  AARM.AUserIncludes: ..\inc; ..\..\..\component\soc\realtek\8710c\cmsis; ..\..\..\component\os\os_dep\include; ..\..\..\component\os\freertos\freertos_v10.0.1\Source\include; ..\..\..\component\os\freertos\freertos_v10.0.1\Source\portable\IAR\ARM_RTL8710C
  OBJCOPY.OOCOutputFile: application_is.srec
  prebuild: CSCRIPT  "..\..\..\component\soc\realtek\8710c\misc\iar_utility\prebuild.vbs" "$PROJ_DIR$"
  postbuild: CSCRIPT  "..\..\..\component\soc\realtek\8710c\misc\iar_utility\postbuild_is.vbs" "$TARGET_DIR$" "$PROJ_DIR$" "$CONFIG_NAME$" "$TOOLKIT_DIR$"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkKeepSymbols: ram_start
  ILINK.IlinkIcfFile: application_is.icf
  ILINK.IlinkExtraOptions: --redirect malloc=__wrap_malloc; --redirect realloc=__wrap_realloc; --redirect free=__wrap_free; --redirect memcmp=__wrap_memcmp; --redirect memcpy=__wrap_memcpy; --redirect memmove=__wrap_memmove; --redirect memset=__wrap_memset; --redirect strcat=__wrap_strcat; --redirect strchr=__wrap_strchr; --redirect strcmp=__wrap_strcmp; --redirect strncmp=__wrap_strncmp; --redirect strnicmp=__wrap_strnicmp; --redirect strcpy=__wrap_strcpy; --redirect strncpy=__wrap_strncpy; --redirect strlcpy=__wrap_strlcpy; --redirect strlen=__wrap_strlen; --redirect strnlen=__wrap_strnlen; --redirect strncat=__wrap_strncat; --redirect strpbrk=__wrap_strpbrk; --redirect strspn=__wrap_strspn; --redirect strstr=__wrap_strstr; --redirect strtok=__wrap_strtok; --redirect strxfrm=__wrap_strxfrm; --redirect strsep=__wrap_strsep; --redirect strtod=__wrap_strtod; --redirect strtof=__wrap_strtof; --redirect strtold=__wrap_strtold; --redirect strtoll=__wrap_strtoll; --redirect strtoul=__wrap_strtoul; --redirect strtoull=__wrap_strtoull; --redirect atoi=__wrap_atoi; --redirect atoui=__wrap_atoui; --redirect atol=__wrap_atol; --redirect atoul=__wrap_atoul; --redirect atoull=__wrap_atoull; --redirect atof=__wrap_atof; --skip_dynamic_initialization; --redirect aesccmp_construct_mic_iv=aesccmp_construct_mic_iv_ram; --redirect aesccmp_construct_mic_header1=aesccmp_construct_mic_header1_ram; --redirect aesccmp_construct_ctr_preload=aesccmp_construct_ctr_preload_ram; --redirect rom_psk_CalcGTK=ram_patch_rom_psk_CalcGTK; --redirect rom_psk_CalcPTK=ram_patch_rom_psk_CalcPTK; --redirect aes_80211_encrypt=ram_patch_aes_80211_encrypt; --redirect aes_80211_decrypt=ram_patch_aes_80211_decrypt
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group @SRAM
    ../../../component/common/mbed/targets/hal/rtl8710c/: flash_api.c power_mode_api.c
    ../../../component/soc/realtek/8710c/misc/driver/: flash_api_ext.c
    ../../../component/common/file_system/fatfs/disk_if/src/: flash_fatfs.c
    ../../../component/soc/realtek/8710c/fwlib/source/ram_ns/: hal_flash.c hal_spic.c
  group azure/src/azure/core
    ../../../component/common/application/azure/azure-sdk-for-c/sdk/src/azure/core/: az_context.c az_http_pipeline.c az_http_policy.c az_http_policy_logging.c az_http_policy_retry.c az_http_request.c az_http_response.c az_json_reader.c az_json_token.c az_json_writer.c az_log.c az_precondition.c az_span.c
  group azure/src/azure/iot
    ../../../component/common/application/azure/azure-sdk-for-c/sdk/src/azure/iot/: az_iot_common.c az_iot_hub_client.c az_iot_hub_client_c2d.c az_iot_hub_client_methods.c az_iot_hub_client_sas.c az_iot_hub_client_telemetry.c az_iot_hub_client_twin.c az_iot_provisioning_client.c az_iot_provisioning_client_sas.c
  group azure/src/azure/platform
    ../../../component/common/application/azure/azure-sdk-for-c/sdk/src/azure/platform/: az_ameba.c
  group cmsis
    ../../../component/soc/realtek/8710c/cmsis/rtl8710c/source/ram_s/: app_start.c
    ../../../component/soc/realtek/8710c/misc/utilities/source/ram/: libc_wrap.c
    ../../../component/soc/realtek/8710c/cmsis/rtl8710c/source/ram/: mpu_config.c sys_irq.c
  group console
    ../../../component/common/api/at_cmd/: atcmd_isp.c atcmd_lwip.c atcmd_media.c atcmd_mp.c atcmd_mp_ext2.c atcmd_sys.c atcmd_wifi.c log_service.c
    ../../../component/soc/realtek/8710c/app/shell/: cmd_shell.c
    ../../../component/soc/realtek/8710c/app/shell/ram_s/: consol_cmds.c
    ../../../component/soc/realtek/8710c/misc/driver/: low_level_io.c rtl_console.c
  group lib
    ../../../component/soc/realtek/8710c/fwlib/lib/lib/: hal_pmc.a
    ../../../component/soc/realtek/8710c/misc/bsp/lib/common/IAR/: lib_dct.a lib_eap.a lib_googlenest.a lib_http.a lib_p2p.a lib_soc_is.a lib_websocket.a lib_wlan.a lib_wps.a
  group network/api
    ../../../component/common/api/: lwip_netconf.c
  group network/api/wifi
    ../../../component/common/api/wifi/: wifi_conf.c wifi_ind.c wifi_promisc.c wifi_simple_config.c wifi_util.c
  group network/api/wifi/rtw_wpa_supplicant
    ../../../component/common/api/wifi/rtw_wpa_supplicant/src/crypto/: tls_polarssl.c
    ../../../component/common/api/wifi/rtw_wpa_supplicant/wpa_supplicant/: wifi_eap_config.c wifi_p2p_config.c wifi_wps_config.c
  group network/app
    ../../../component/soc/realtek/8710c/misc/platform/: ota_8710c.c
    ../../../component/common/api/network/src/: ping_test.c wlan_network.c
    ../../../component/common/utilities/: ssl_client.c ssl_client_ext.c tcptest.c
  group network/app/mqtt
    ../../../component/common/application/mqtt/MQTTClient/: MQTTClient.c MQTTFreertos.c
    ../../../component/common/application/mqtt/MQTTPacket/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group network/coap
    ../../../component/common/network/coap/: sn_coap_ameba_port.c sn_coap_builder.c sn_coap_header_check.c sn_coap_parser.c sn_coap_protocol.c
  group network/http
    ../../../component/common/network/httpc/: httpc_tls.c
    ../../../component/common/network/httpd/: httpd_tls.c
  group network/lwip
    ../../../component/common/network/dhcp/: dhcps.c
    ../../../component/common/network/sntp/: sntp.c
  group network/lwip/api
    ../../../component/common/network/lwip/lwip_v2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group network/lwip/core
    ../../../component/common/network/lwip/lwip_v2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group network/lwip/core/ipv4
    ../../../component/common/network/lwip/lwip_v2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group network/lwip/core/ipv6
    ../../../component/common/network/lwip/lwip_v2.0.2/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group network/lwip/netif
    ../../../component/common/network/lwip/lwip_v2.0.2/src/netif/: ethernet.c
  group network/lwip/port
    ../../../component/common/network/lwip/lwip_v2.0.2/port/realtek/freertos/: ethernetif.c sys_arch.c
    ../../../component/common/drivers/wlan/realtek/src/osdep/: lwip_intf.c
  group network/mdns
    ../../../component/common/network/mDNS/: mDNSPlatform.c
  group network/ssl/mbedtls
    ../../../component/common/network/ssl/mbedtls-2.4.0/library/: aesni.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c debug.c entropy.c error.c gcm.c havege.c md.c md2.c md4.c md_wrap.c memory_buffer_alloc.c net_sockets.c padlock.c pkcs11.c pkcs12.c pkcs5.c pkparse.c platform.c ripemd160.c sha256.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group network/ssl/ssl_ram_map
    ../../../component/common/network/ssl/ssl_ram_map/rom/: rom_ssl_ram_map.c
    ../../../component/common/network/ssl/ssl_func_stubs/: ssl_func_stubs.c
  group network/websocket
    ../../../component/common/network/websocket/: wsclient_tls.c wsserver_tls.c
  group os
    ../../../component/os/freertos/: cmsis_os.c freertos_cb.c freertos_pmu.c freertos_service.c
    ../../../component/os/os_dep/: device_lock.c osdep_service.c
  group os/freertos
    ../../../component/os/freertos/freertos_v10.0.1/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group os/freertos/portable
    ../../../component/os/freertos/freertos_v10.0.1/Source/portable/MemMang/: heap_5.c
    ../../../component/os/freertos/freertos_v10.0.1/Source/portable/IAR/ARM_RTL8710C/: port.c portasm.s
  group peripheral/api
    ../../../component/common/mbed/targets/hal/rtl8710c/: crypto_api.c dma_api.c efuse_api.c gpio_api.c gpio_irq_api.c i2c_api.c pinmap.c pinmap_common.c port_api.c pwmout_api.c reset_reason_api.c rtc_api.c serial_api.c spdio_api.c spi_api.c sys_api.c timer_api.c us_ticker.c us_ticker_api.c wait_api.c wdt_api.c
  group peripheral/hal
    ../../../component/soc/realtek/8710c/fwlib/source/ram_s/: hal_efuse.c hal_pinmux_nsc.c
    ../../../component/soc/realtek/8710c/fwlib/source/ram/: hal_gdma.c hal_gpio.c hal_misc.c hal_uart.c
    ../../../component/soc/realtek/8710c/fwlib/source/ram_ns/: hal_i2c.c hal_pwm.c hal_sdio_dev.c hal_ssi.c
  group peripheral/wlan
    ../../../component/common/drivers/wlan/realtek/src/core/option/: rtw_opt_rf_para_rtl8710c.c rtw_opt_skbuf.c
  group user
    ../src/: main.c
  group utilities
    ../../../component/common/utilities/: cJSON.c http_client.c xml.c
  group utilities/example
    ../../../component/common/example/amazon_awsiot/: example_amazon_awsiot.c
    ../../../component/common/example/bcast/: example_bcast.c
    ../../../component/common/example/cJSON/: example_cJSON.c
    ../../../component/common/example/coap/: example_coap.c
    ../../../component/common/example/dct/: example_dct.c
    ../../../component/common/example/eap/: example_eap.c
    ../../../component/common/example/: example_entry.c
    ../../../component/common/example/fatfs/: example_fatfs.c
    ../../../component/common/example/get_beacon_frame/: example_get_beacon_frame.c
    ../../../component/common/example/high_load_memory_use/: example_high_load_memory_use.c
    ../../../component/common/example/http_client/: example_http_client.c
    ../../../component/common/example/http_download/: example_http_download.c
    ../../../component/common/example/httpc/: example_httpc.c
    ../../../component/common/example/httpd/: example_httpd.c
    ../../../component/common/example/mcast/: example_mcast.c
    ../../../component/common/example/mqtt/: example_mqtt.c
    ../../../component/common/example/nonblock_connect/: example_nonblock_connect.c
    ../../../component/common/example/ota_http/: example_ota_http.c
    ../../../component/common/example/rarp/: example_rarp.c
    ../../../component/common/example/sntp_showtime/: example_sntp_showtime.c
    ../../../component/common/example/socket_select/: example_socket_select.c
    ../../../component/common/example/socket_tcp_trx/: example_socket_tcp_trx_1.c example_socket_tcp_trx_2.c
    ../../../component/common/example/ssl_download/: example_ssl_download.c
    ../../../component/common/example/ssl_server/: example_ssl_server.c
    ../../../component/common/example/tcp_keepalive/: example_tcp_keepalive.c
    ../../../component/common/example/uart_atcmd/: example_uart_atcmd.c
    ../../../component/common/example/wifi_mac_monitor/: example_wifi_mac_monitor.c
    ../../../component/common/example/wifi_roaming/: example_wifi_roaming.c
    ../../../component/common/example/wlan_fast_connect/: example_wlan_fast_connect.c
    ../../../component/common/example/wlan_scenario/: example_wlan_scenario.c
    ../../../component/common/example/websocket_client/: example_wsclient.c
    ../../../component/common/example/xml/: example_xml.c
  group utilities/example/example_azure_iot
    ../../../component/common/example/azure/: example_azure_iot_common.c example_azure_iot_entry.c example_azure_iot_hub_c2d.c example_azure_iot_hub_methods.c example_azure_iot_hub_pnp.c example_azure_iot_hub_pnp_component.c example_azure_iot_hub_sas_telemetry.c example_azure_iot_hub_telemetry.c example_azure_iot_hub_twin.c example_azure_iot_provisioning.c example_azure_iot_provisioning_sas.c example_azure_iot_rtk_pnp_sas.c example_azure_iot_rtk_pnp_x509.c
  group utilities/example/example_azure_iot/pnp
    ../../../component/common/example/azure/pnp/: pnp_mqtt_message.c pnp_protocol.c
  group utilities/example/example_azure_iot/pnp/rtk_component
    ../../../component/common/example/azure/pnp/rtk_component/: pnp_audio.c pnp_bluetooth.c pnp_device_info.c pnp_gpio.c pnp_lcd.c pnp_memory.c pnp_system.c pnp_video.c pnp_wireless.c
  group utilities/example/example_azure_iot/pnp/rtk_message
    ../../../component/common/example/azure/pnp/rtk_message/: pnp_common_message.c
  group utilities/example/example_azure_iot/pnp/sample_component
    ../../../component/common/example/azure/pnp/sample_component/: pnp_device_info_component.c pnp_thermostat_component.c
  group utilities/FatFs/disk_if
    ../../../component/common/file_system/fatfs/disk_if/src/: sdcard.c usbdisk.c
    ../../../component/common/drivers/sdio/realtek/sdio_host/src/: sdio_combine.c
  group utilities/FatFs/fatfs_ext
    ../../../component/common/file_system/fatfs/fatfs_ext/src/: ff_driver.c
  group utilities/FatFs/r0.10c
    ../../../component/common/file_system/fatfs/r0.10c/src/: diskio.c ff.c
  group utilities/FatFs/r0.10c/option
    ../../../component/common/file_system/fatfs/r0.10c/src/option/: ccsbcs.c
