<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\application_is.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_amazon.ewp</path>
    </project>
    <batchBuild />
</workspace>
